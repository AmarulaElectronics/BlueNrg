<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\Central_Lib.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>BUILD_ALL</name>
      <member>
        <project>Central_Lib</project>
        <configuration>ANC</configuration>
      </member>
      <member>
        <project>Central_Lib</project>
        <configuration>ANS</configuration>
      </member>
      <member>
        <project>Central_Lib</project>
        <configuration>BPC</configuration>
      </member>
      <member>
        <project>Central_Lib</project>
        <configuration>FML</configuration>
      </member>
      <member>
        <project>Central_Lib</project>
        <configuration>FMT</configuration>
      </member>
      <member>
        <project>Central_Lib</project>
        <configuration>GLC</configuration>
      </member>
      <member>
        <project>Central_Lib</project>
        <configuration>HID</configuration>
      </member>
      <member>
        <project>Central_Lib</project>
        <configuration>HRC</configuration>
      </member>
      <member>
        <project>Central_Lib</project>
        <configuration>HTC</configuration>
      </member>
      <member>
        <project>Central_Lib</project>
        <configuration>PASS</configuration>
      </member>
      <member>
        <project>Central_Lib</project>
        <configuration>PXM</configuration>
      </member>
      <member>
        <project>Central_Lib</project>
        <configuration>PXR</configuration>
      </member>
      <member>
        <project>Central_Lib</project>
        <configuration>TIC</configuration>
      </member>
      <member>
        <project>Central_Lib</project>
        <configuration>TIS</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


