# IAR project Central_Lib.ewp, settings and files
configuration ANC (ARM)
  General.OGChipSelectEditMenu: BlueNRG-1 ST BlueNRG-1
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: DEBUG; HS_SPEED_XTAL=HS_SPEED_XTAL_16MHZ; LS_SOURCE=LS_SOURCE_EXTERNAL_32KHZ; SMPS_INDUCTOR=SMPS_INDUCTOR_10uH; BLE_STACK_CONFIGURATION=BLE_STACK_FULL_CONFIGURATION; ENABLE_USB; ENABLE_USB_PRINTF; BLE_CURRENT_PROFILE_ROLES=ALERT_NOTIFICATION_CLIENT; BLE_2_X=1
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\..\inc; ..\..\..\..\..\Library\hal\inc; ..\..\..\..\..\Library\BlueNRG1_Periph_Driver\inc; ..\..\..\..\..\Library\CMSIS\Device\ST\BlueNRG1\Include; ..\..\..\..\..\Library\CMSIS\Include; ..\..\..\..\..\Library\Bluetooth_LE\inc; ..\..\..\..\..\Library\BLE_Application\layers_inc; ..\..\..\..\..\Library\BLE_Application\Utils\inc; ..\..\..\..\..\Library\BLE_Application\OTA\inc; ..\..\..\..\..\Library\SDK_Eval_BlueNRG1\inc; ..\..\..\..\..\Library\BLE_Application\Profile_Central\includes
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ANC_Profile.hex
  ILINK.IlinkOutputFile: ANC_Profile.out
  ILINK.IlinkIcfFile: BlueNRG1.icf
  ILINK.IlinkAdditionalLibs: ..\..\..\..\..\Library\BLE_Application\Profile_Central\library\Debug\libAlert_Notification_Client_Central_Debug_BlueNRG-1.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration ANS (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: DEBUG; HS_SPEED_XTAL=HS_SPEED_XTAL_16MHZ; LS_SOURCE=LS_SOURCE_EXTERNAL_32KHZ; SMPS_INDUCTOR=SMPS_INDUCTOR_10uH; BLE_STACK_CONFIGURATION=BLE_STACK_FULL_CONFIGURATION; ENABLE_USB; ENABLE_USB_PRINTF; BLE_CURRENT_PROFILE_ROLES=ALERT_NOTIFICATION_SERVER; BLE_2_X=1
  OBJCOPY.OOCOutputFile: ANS_Profile.hex
  ILINK.IlinkOutputFile: ANS_Profile.out
  ILINK.IlinkAdditionalLibs: ..\..\..\..\..\Library\BLE_Application\Profile_Central\library\Debug\libAlert_Notification_Server_Central_Debug_BlueNRG-1.a
configuration BPC (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: DEBUG; HS_SPEED_XTAL=HS_SPEED_XTAL_16MHZ; LS_SOURCE=LS_SOURCE_EXTERNAL_32KHZ; SMPS_INDUCTOR=SMPS_INDUCTOR_10uH; BLE_STACK_CONFIGURATION=BLE_STACK_FULL_CONFIGURATION; ENABLE_USB; ENABLE_USB_PRINTF; BLE_CURRENT_PROFILE_ROLES=BLOOD_PRESSURE_COLLECTOR; BLE_2_X=1
  OBJCOPY.OOCOutputFile: BPC_Profile.hex
  ILINK.IlinkOutputFile: BPC_Profile.out
  ILINK.IlinkAdditionalLibs: ..\..\..\..\..\Library\BLE_Application\Profile_Central\library\Debug\libBlood_Pressure_Collector_Central_Debug_BlueNRG-1.a
configuration FML (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: DEBUG; HS_SPEED_XTAL=HS_SPEED_XTAL_16MHZ; LS_SOURCE=LS_SOURCE_EXTERNAL_32KHZ; SMPS_INDUCTOR=SMPS_INDUCTOR_10uH; BLE_STACK_CONFIGURATION=BLE_STACK_FULL_CONFIGURATION; ENABLE_USB; ENABLE_USB_PRINTF; BLE_CURRENT_PROFILE_ROLES=FIND_ME_LOCATOR; BLE_2_X=1
  OBJCOPY.OOCOutputFile: FML_Profile.hex
  ILINK.IlinkOutputFile: FML_Profile.out
  ILINK.IlinkAdditionalLibs: ..\..\..\..\..\Library\BLE_Application\Profile_Central\library\Debug\libFind_Me_Locator_Central_Debug_BlueNRG-1.a
configuration FMT (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: DEBUG; HS_SPEED_XTAL=HS_SPEED_XTAL_16MHZ; LS_SOURCE=LS_SOURCE_EXTERNAL_32KHZ; SMPS_INDUCTOR=SMPS_INDUCTOR_10uH; BLE_STACK_CONFIGURATION=BLE_STACK_FULL_CONFIGURATION; ENABLE_USB; ENABLE_USB_PRINTF; BLE_CURRENT_PROFILE_ROLES=FIND_ME_TARGET; BLE_2_X=1
  OBJCOPY.OOCOutputFile: FMT_Profile.hex
  ILINK.IlinkOutputFile: FMT_Profile.out
  ILINK.IlinkAdditionalLibs: ..\..\..\..\..\Library\BLE_Application\Profile_Central\library\Debug\libFind_Me_Target_Central_Debug_BlueNRG-1.a
configuration GLC (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: DEBUG; HS_SPEED_XTAL=HS_SPEED_XTAL_16MHZ; LS_SOURCE=LS_SOURCE_EXTERNAL_32KHZ; SMPS_INDUCTOR=SMPS_INDUCTOR_10uH; BLE_STACK_CONFIGURATION=BLE_STACK_FULL_CONFIGURATION; ENABLE_USB; ENABLE_USB_PRINTF; BLE_CURRENT_PROFILE_ROLES=GLUCOSE_COLLECTOR; BLE_2_X=1
  OBJCOPY.OOCOutputFile: GLC_Profile.hex
  ILINK.IlinkOutputFile: GLC_Profile.out
  ILINK.IlinkAdditionalLibs: ..\..\..\..\..\Library\BLE_Application\Profile_Central\library\Debug\libGlucose_Collector_Central_Debug_BlueNRG-1.a
configuration HID (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: DEBUG; HS_SPEED_XTAL=HS_SPEED_XTAL_16MHZ; LS_SOURCE=LS_SOURCE_EXTERNAL_32KHZ; SMPS_INDUCTOR=SMPS_INDUCTOR_10uH; BLE_STACK_CONFIGURATION=BLE_STACK_FULL_CONFIGURATION; ENABLE_USB; ENABLE_USB_PRINTF; BLE_CURRENT_PROFILE_ROLES=HID_HOST; BLE_2_X=1
  OBJCOPY.OOCOutputFile: HID_Profile.hex
  ILINK.IlinkOutputFile: HID_Profile.out
  ILINK.IlinkAdditionalLibs: ..\..\..\..\..\Library\BLE_Application\Profile_Central\library\Debug\libHID_Host_Central_Debug_BlueNRG-1.a
configuration HRC (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: HS_SPEED_XTAL=HS_SPEED_XTAL_16MHZ; LS_SOURCE=LS_SOURCE_EXTERNAL_32KHZ; SMPS_INDUCTOR=SMPS_INDUCTOR_10uH; BLE_STACK_CONFIGURATION=BLE_STACK_FULL_CONFIGURATION; ENABLE_USB; ENABLE_USB_PRINTF; DEBUG; BLE_CURRENT_PROFILE_ROLES=HEART_RATE_COLLECTOR; BLE_2_X=1
  OBJCOPY.OOCOutputFile: HRC_Profile.hex
  ILINK.IlinkOutputFile: HRC_Profile.out
  ILINK.IlinkAdditionalLibs: ..\..\..\..\..\Library\BLE_Application\Profile_Central\library\Debug\libHeart_Rate_Collector_Central_Debug_BlueNRG-1.a
configuration HTC (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: DEBUG; HS_SPEED_XTAL=HS_SPEED_XTAL_16MHZ; LS_SOURCE=LS_SOURCE_EXTERNAL_32KHZ; SMPS_INDUCTOR=SMPS_INDUCTOR_10uH; BLE_STACK_CONFIGURATION=BLE_STACK_FULL_CONFIGURATION; ENABLE_USB; ENABLE_USB_PRINTF; BLE_CURRENT_PROFILE_ROLES=HEALTH_THERMOMETER_COLLECTOR; BLE_2_X=1
  OBJCOPY.OOCOutputFile: HTC_Profile.hex
  ILINK.IlinkOutputFile: HTC_Profile.out
  ILINK.IlinkAdditionalLibs: ..\..\..\..\..\Library\BLE_Application\Profile_Central\library\Debug\libHealth_Thermometer_Collector_Central_Debug_BlueNRG-1.a
configuration PASS (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: DEBUG; HS_SPEED_XTAL=HS_SPEED_XTAL_16MHZ; LS_SOURCE=LS_SOURCE_EXTERNAL_32KHZ; SMPS_INDUCTOR=SMPS_INDUCTOR_10uH; BLE_STACK_CONFIGURATION=BLE_STACK_FULL_CONFIGURATION; ENABLE_USB; ENABLE_USB_PRINTF; BLE_CURRENT_PROFILE_ROLES=PHONE_ALERT_STATUS_SERVER; BLE_2_X=1
  OBJCOPY.OOCOutputFile: PASS_Profile.hex
  ILINK.IlinkOutputFile: PASS_Profile.out
  ILINK.IlinkAdditionalLibs: ..\..\..\..\..\Library\BLE_Application\Profile_Central\library\Debug\libPhone_Alert_Status_Server_Central_Debug_BlueNRG-1.a
configuration PXM (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: DEBUG; HS_SPEED_XTAL=HS_SPEED_XTAL_16MHZ; LS_SOURCE=LS_SOURCE_EXTERNAL_32KHZ; SMPS_INDUCTOR=SMPS_INDUCTOR_10uH; BLE_STACK_CONFIGURATION=BLE_STACK_FULL_CONFIGURATION; ENABLE_USB; ENABLE_USB_PRINTF; BLE_CURRENT_PROFILE_ROLES=PROXIMITY_MONITOR; BLE_2_X=1
  OBJCOPY.OOCOutputFile: PXM_Profile.hex
  ILINK.IlinkOutputFile: PXM_Profile.out
  ILINK.IlinkAdditionalLibs: ..\..\..\..\..\Library\BLE_Application\Profile_Central\library\Debug\libProximity_Monitor_Central_Debug_BlueNRG-1.a
configuration PXR (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: DEBUG; HS_SPEED_XTAL=HS_SPEED_XTAL_16MHZ; LS_SOURCE=LS_SOURCE_EXTERNAL_32KHZ; SMPS_INDUCTOR=SMPS_INDUCTOR_10uH; BLE_STACK_CONFIGURATION=BLE_STACK_FULL_CONFIGURATION; ENABLE_USB; ENABLE_USB_PRINTF; BLE_CURRENT_PROFILE_ROLES=PROXIMITY_REPORTER; BLE_2_X=1
  OBJCOPY.OOCOutputFile: PXR_Profile.hex
  ILINK.IlinkOutputFile: PXR_Profile.out
  ILINK.IlinkAdditionalLibs: ..\..\..\..\..\Library\BLE_Application\Profile_Central\library\Debug\libProximity_Reporter_Central_Debug_BlueNRG-1.a
configuration TIC (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: DEBUG; HS_SPEED_XTAL=HS_SPEED_XTAL_16MHZ; LS_SOURCE=LS_SOURCE_EXTERNAL_32KHZ; SMPS_INDUCTOR=SMPS_INDUCTOR_10uH; BLE_STACK_CONFIGURATION=BLE_STACK_FULL_CONFIGURATION; ENABLE_USB; ENABLE_USB_PRINTF; BLE_CURRENT_PROFILE_ROLES=TIME_CLIENT; BLE_2_X=1
  OBJCOPY.OOCOutputFile: TIC_Profile.hex
  ILINK.IlinkOutputFile: TIC_Profile.out
  ILINK.IlinkAdditionalLibs: ..\..\..\..\..\Library\BLE_Application\Profile_Central\library\Debug\libTime_Client_Central_Debug_BlueNRG-1.a
configuration TIS (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: DEBUG; HS_SPEED_XTAL=HS_SPEED_XTAL_16MHZ; LS_SOURCE=LS_SOURCE_EXTERNAL_32KHZ; SMPS_INDUCTOR=SMPS_INDUCTOR_10uH; BLE_STACK_CONFIGURATION=BLE_STACK_FULL_CONFIGURATION; ENABLE_USB; ENABLE_USB_PRINTF; BLE_CURRENT_PROFILE_ROLES=TIME_SERVER; BLE_2_X=1
  OBJCOPY.OOCOutputFile: TIS_Profile.hex
  ILINK.IlinkOutputFile: TIS_Profile.out
  ILINK.IlinkAdditionalLibs: ..\..\..\..\..\Library\BLE_Application\Profile_Central\library\Debug\libTime_Server_Central_Debug_BlueNRG-1.a
  group HAL
    ../../../../../Library/hal/src/: clock.c context_switch.s miscutil.c osal.c sleep.c
  group Library
    ../../../../../Library/BlueNRG1_Periph_Driver/src/: BlueNRG1_adc.c BlueNRG1_dma.c BlueNRG1_flash.c BlueNRG1_gpio.c BlueNRG1_i2c.c BlueNRG1_mft.c BlueNRG1_pka.c BlueNRG1_rng.c BlueNRG1_rtc.c BlueNRG1_spi.c BlueNRG1_sysCtrl.c BlueNRG1_uart.c BlueNRG1_wdg.c misc.c
  group Platforms_Layers
    ../../../../../Library/SDK_Eval_BlueNRG1/src/: SDK_EVAL_Button.c SDK_EVAL_Com.c SDK_EVAL_Config.c SDK_EVAL_Led.c
  group Profile_Test/ANC
    ../../../../../Library/BLE_Application/Profile_Central/tests/: profiles_AlertNotificationClient_central_test_application.c
  group Profile_Test/ANS
    ../../../../../Library/BLE_Application/Profile_Central/tests/: profiles_AlertNotificationServer_central_test_application.c
  group Profile_Test/BPC
    ../../../../../Library/BLE_Application/Profile_Central/tests/: profiles_BloodPressure_central_test_application.c
  group Profile_Test/FML
    ../../../../../Library/BLE_Application/Profile_Central/tests/: profiles_FindMeLocator_central_test_application.c
  group Profile_Test/FMT
    ../../../../../Library/BLE_Application/Profile_Central/tests/: profiles_FindMeTarget_central_test_application.c
  group Profile_Test/GLC
    ../../../../../Library/BLE_Application/Profile_Central/tests/: profiles_Glucose_central_test_application.c
  group Profile_Test/HID_host
    ../../../../../Library/BLE_Application/Profile_Central/tests/: profiles_HidHost_central_test_application.c
  group Profile_Test/HRC
    ../../../../../Library/BLE_Application/Profile_Central/tests/: profiles_HR_central_test_application.c
  group Profile_Test/HTC
    ../../../../../Library/BLE_Application/Profile_Central/tests/: profiles_HT_central_test_application.c
  group Profile_Test/PASS
    ../../../../../Library/BLE_Application/Profile_Central/tests/: profiles_PhoneALertStatusServer_central_test_application.c
  group Profile_Test/PXM
    ../../../../../Library/BLE_Application/Profile_Central/tests/: profiles_ProximityMonitor_central_test_application.c
  group Profile_Test/PXR
    ../../../../../Library/BLE_Application/Profile_Central/tests/: profiles_ProximityReporter_central_test_application.c
  group Profile_Test/TIC
    ../../../../../Library/BLE_Application/Profile_Central/tests/: profiles_TimeClient_central_test_application.c
  group Profile_Test/TIS
    ../../../../../Library/BLE_Application/Profile_Central/tests/: profiles_TimeServer_central_test_application.c
  group Profiles/ble_profile
    ../../../../../Library/BLE_Application/Profile_Central/profiles/ble_profile/: master_events_CB.c
  group Stack
    ../../../../../Library/Bluetooth_LE/library/: libbluenrg1_stack.a
    ../../../../../Library/cryptolib/: libcrypto.a
    ../../../../../Library/Bluetooth_LE/src/: stack_user_cfg.c
  group Startup
    ../../../../../Library/CMSIS/Device/ST/BlueNRG1/Source/: system_bluenrg1.c
  group User
    ../../src/: BlueNRG1_it.c main.c
