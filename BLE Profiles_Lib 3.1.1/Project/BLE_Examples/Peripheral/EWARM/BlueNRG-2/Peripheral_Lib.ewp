# IAR project Peripheral_Lib.ewp, settings and files
configuration ANC (ARM)
  General.OGChipSelectEditMenu: BlueNRG-2 ST BlueNRG-2
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: DEBUG; BLUENRG2_DEVICE; HS_SPEED_XTAL=HS_SPEED_XTAL_32MHZ; LS_SOURCE=LS_SOURCE_EXTERNAL_32KHZ; SMPS_INDUCTOR=SMPS_INDUCTOR_10uH; BLE_STACK_CONFIGURATION=BLE_STACK_FULL_CONFIGURATION; BLE_CURRENT_PROFILE_ROLES=ALERT_NOTIFICATION_CLIENT; BLE_2_X=1
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\..\inc; ..\..\..\..\..\Library\hal\inc; ..\..\..\..\..\Library\BlueNRG1_Periph_Driver\inc; ..\..\..\..\..\Library\CMSIS\Device\ST\BlueNRG1\Include; ..\..\..\..\..\Library\CMSIS\Include; ..\..\..\..\..\Library\Bluetooth_LE\inc; ..\..\..\..\..\Library\BLE_Application\layers_inc; ..\..\..\..\..\Library\BLE_Application\Utils\inc; ..\..\..\..\..\Library\BLE_Application\OTA\inc; ..\..\..\..\..\Library\SDK_Eval_BlueNRG1\inc; ..\..\..\..\..\Library\BLE_Application\Profile_Peripheral\includes
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ANC.hex
  ILINK.IlinkOutputFile: ANC.out
  ILINK.IlinkIcfFile: BlueNRG2.icf
  ILINK.IlinkAdditionalLibs: ..\..\..\..\..\Library\BLE_Application\Profile_Peripheral\library\libProfile_Library_Debug_BlueNRG1.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration ANS (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: DEBUG; BLUENRG2_DEVICE; HS_SPEED_XTAL=HS_SPEED_XTAL_32MHZ; LS_SOURCE=LS_SOURCE_EXTERNAL_32KHZ; SMPS_INDUCTOR=SMPS_INDUCTOR_10uH; BLE_STACK_CONFIGURATION=BLE_STACK_FULL_CONFIGURATION; BLE_CURRENT_PROFILE_ROLES=ALERT_NOTIFICATION_SERVER; BLE_2_X=1
  OBJCOPY.OOCOutputFile: ANS.hex
  ILINK.IlinkOutputFile: ANS.out
configuration BPS (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: DEBUG; BLUENRG2_DEVICE; HS_SPEED_XTAL=HS_SPEED_XTAL_32MHZ; LS_SOURCE=LS_SOURCE_EXTERNAL_32KHZ; SMPS_INDUCTOR=SMPS_INDUCTOR_10uH; BLE_STACK_CONFIGURATION=BLE_STACK_FULL_CONFIGURATION; BLE_CURRENT_PROFILE_ROLES=BLOOD_PRESSURE_SENSOR; BLE_2_X=1
  OBJCOPY.OOCOutputFile: BPS.hex
  ILINK.IlinkOutputFile: BPS.out
configuration FML (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: DEBUG; BLUENRG2_DEVICE; HS_SPEED_XTAL=HS_SPEED_XTAL_32MHZ; LS_SOURCE=LS_SOURCE_EXTERNAL_32KHZ; SMPS_INDUCTOR=SMPS_INDUCTOR_10uH; BLE_STACK_CONFIGURATION=BLE_STACK_FULL_CONFIGURATION; BLE_CURRENT_PROFILE_ROLES=FIND_ME_LOCATOR; BLE_2_X=1
  OBJCOPY.OOCOutputFile: FML.hex
  ILINK.IlinkOutputFile: FML.out
configuration FMT (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: DEBUG; BLUENRG2_DEVICE; HS_SPEED_XTAL=HS_SPEED_XTAL_32MHZ; LS_SOURCE=LS_SOURCE_EXTERNAL_32KHZ; SMPS_INDUCTOR=SMPS_INDUCTOR_10uH; BLE_STACK_CONFIGURATION=BLE_STACK_FULL_CONFIGURATION; BLE_CURRENT_PROFILE_ROLES=FIND_ME_TARGET; BLE_2_X=1
  OBJCOPY.OOCOutputFile: FMT.hex
  ILINK.IlinkOutputFile: FMT.out
configuration GLS (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: DEBUG; BLUENRG2_DEVICE; HS_SPEED_XTAL=HS_SPEED_XTAL_32MHZ; LS_SOURCE=LS_SOURCE_EXTERNAL_32KHZ; SMPS_INDUCTOR=SMPS_INDUCTOR_10uH; BLE_STACK_CONFIGURATION=BLE_STACK_FULL_CONFIGURATION; BLE_CURRENT_PROFILE_ROLES=GLUCOSE_SENSOR; BLE_2_X=1
  OBJCOPY.OOCOutputFile: GLS.hex
  ILINK.IlinkOutputFile: GLS.out
configuration HTS (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: DEBUG; BLUENRG2_DEVICE; HS_SPEED_XTAL=HS_SPEED_XTAL_32MHZ; LS_SOURCE=LS_SOURCE_EXTERNAL_32KHZ; SMPS_INDUCTOR=SMPS_INDUCTOR_10uH; BLE_STACK_CONFIGURATION=BLE_STACK_FULL_CONFIGURATION; BLE_CURRENT_PROFILE_ROLES=HEALTH_THERMOMETER; BLE_2_X=1
  OBJCOPY.OOCOutputFile: HTS.hex
  ILINK.IlinkOutputFile: HTS.out
configuration HRS (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: DEBUG; BLUENRG2_DEVICE; HS_SPEED_XTAL=HS_SPEED_XTAL_32MHZ; LS_SOURCE=LS_SOURCE_EXTERNAL_32KHZ; SMPS_INDUCTOR=SMPS_INDUCTOR_10uH; BLE_STACK_CONFIGURATION=BLE_STACK_FULL_CONFIGURATION; BLE_CURRENT_PROFILE_ROLES=HEART_RATE_SENSOR; BLE_2_X=1
  OBJCOPY.OOCOutputFile: HRS.hex
  ILINK.IlinkOutputFile: HRS_Release.out
configuration PAC (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: DEBUG; BLUENRG2_DEVICE; HS_SPEED_XTAL=HS_SPEED_XTAL_32MHZ; LS_SOURCE=LS_SOURCE_EXTERNAL_32KHZ; SMPS_INDUCTOR=SMPS_INDUCTOR_10uH; BLE_STACK_CONFIGURATION=BLE_STACK_FULL_CONFIGURATION; BLE_CURRENT_PROFILE_ROLES=PHONE_ALERT_CLIENT; BLE_2_X=1
  OBJCOPY.OOCOutputFile: PAC.hex
  ILINK.IlinkOutputFile: PAC.out
configuration PXM (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: DEBUG; BLUENRG2_DEVICE; HS_SPEED_XTAL=HS_SPEED_XTAL_32MHZ; LS_SOURCE=LS_SOURCE_EXTERNAL_32KHZ; SMPS_INDUCTOR=SMPS_INDUCTOR_10uH; BLE_STACK_CONFIGURATION=BLE_STACK_FULL_CONFIGURATION; BLE_CURRENT_PROFILE_ROLES=PROXIMITY_MONITOR; BLE_2_X=1
  OBJCOPY.OOCOutputFile: PXM.hex
  ILINK.IlinkOutputFile: PXM.out
configuration PXR (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: DEBUG; BLUENRG2_DEVICE; HS_SPEED_XTAL=HS_SPEED_XTAL_32MHZ; LS_SOURCE=LS_SOURCE_EXTERNAL_32KHZ; SMPS_INDUCTOR=SMPS_INDUCTOR_10uH; BLE_STACK_CONFIGURATION=BLE_STACK_FULL_CONFIGURATION; BLE_CURRENT_PROFILE_ROLES=PROXIMITY_REPORTER; BLE_2_X=1
  OBJCOPY.OOCOutputFile: PXR.hex
  ILINK.IlinkOutputFile: PXR.out
configuration TIC (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: DEBUG; BLUENRG2_DEVICE; HS_SPEED_XTAL=HS_SPEED_XTAL_32MHZ; LS_SOURCE=LS_SOURCE_EXTERNAL_32KHZ; SMPS_INDUCTOR=SMPS_INDUCTOR_10uH; BLE_STACK_CONFIGURATION=BLE_STACK_FULL_CONFIGURATION; BLE_CURRENT_PROFILE_ROLES=TIME_CLIENT; BLE_2_X=1
  OBJCOPY.OOCOutputFile: TIC.hex
  ILINK.IlinkOutputFile: TIC.out
configuration TIS (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: DEBUG; BLUENRG2_DEVICE; HS_SPEED_XTAL=HS_SPEED_XTAL_32MHZ; LS_SOURCE=LS_SOURCE_EXTERNAL_32KHZ; SMPS_INDUCTOR=SMPS_INDUCTOR_10uH; BLE_STACK_CONFIGURATION=BLE_STACK_FULL_CONFIGURATION; BLE_CURRENT_PROFILE_ROLES=TIME_SERVER; BLE_2_X=1
  OBJCOPY.OOCOutputFile: TIS.hex
  ILINK.IlinkOutputFile: TIS.out
configuration CGM (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: DEBUG; BLUENRG2_DEVICE; HS_SPEED_XTAL=HS_SPEED_XTAL_32MHZ; LS_SOURCE=LS_SOURCE_EXTERNAL_32KHZ; SMPS_INDUCTOR=SMPS_INDUCTOR_10uH; BLE_STACK_CONFIGURATION=BLE_STACK_FULL_CONFIGURATION; BLE_CURRENT_PROFILE_ROLES=CGM_SENSOR; BLE_2_X=1
  OBJCOPY.OOCOutputFile: CGM.hex
  ILINK.IlinkOutputFile: CGM.out
  group HAL
    ../../../../../Library/hal/src/: clock.c context_switch.s miscutil.c osal.c sleep.c
  group Library
    ../../../../../Library/BlueNRG1_Periph_Driver/src/: BlueNRG1_adc.c BlueNRG1_dma.c BlueNRG1_flash.c BlueNRG1_gpio.c BlueNRG1_i2c.c BlueNRG1_mft.c BlueNRG1_pka.c BlueNRG1_rng.c BlueNRG1_rtc.c BlueNRG1_spi.c BlueNRG1_sysCtrl.c BlueNRG1_uart.c BlueNRG1_wdg.c misc.c
  group Platforms_Layers
    ../../../../../Library/SDK_Eval_BlueNRG1/src/: SDK_EVAL_Button.c SDK_EVAL_Com.c SDK_EVAL_Config.c SDK_EVAL_I2C.c SDK_EVAL_Led.c SDK_EVAL_SPI.c
  group Profile_Test
    ../../../../../Library/BLE_Application/Profile_Peripheral/test/: profiles_test_application.c
  group profiles/ble_profile
    ../../../../../Library/BLE_Application/Profile_Peripheral/profiles/ble_profile/: list.c profile.c profiles_events.c
  group Stack
    ../../../../../Library/Bluetooth_LE/library/: libbluenrg1_stack.a
    ../../../../../Library/cryptolib/: libcrypto.a
    ../../../../../Library/Bluetooth_LE/src/: stack_user_cfg.c
  group Startup
    ../../../../../Library/CMSIS/Device/ST/BlueNRG1/Source/: system_bluenrg1.c
  group User
    ../../src/: BlueNRG1_it.c main.c
