<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\Peripheral_Lib.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>BUILD_ALL</name>
      <member>
        <project>Peripheral_Lib</project>
        <configuration>ANC</configuration>
      </member>
      <member>
        <project>Peripheral_Lib</project>
        <configuration>ANS</configuration>
      </member>
      <member>
        <project>Peripheral_Lib</project>
        <configuration>BPS</configuration>
      </member>
      <member>
        <project>Peripheral_Lib</project>
        <configuration>FML</configuration>
      </member>
      <member>
        <project>Peripheral_Lib</project>
        <configuration>FMT</configuration>
      </member>
      <member>
        <project>Peripheral_Lib</project>
        <configuration>GLS</configuration>
      </member>
      <member>
        <project>Peripheral_Lib</project>
        <configuration>HRS</configuration>
      </member>
      <member>
        <project>Peripheral_Lib</project>
        <configuration>HTS</configuration>
      </member>
      <member>
        <project>Peripheral_Lib</project>
        <configuration>PAC</configuration>
      </member>
      <member>
        <project>Peripheral_Lib</project>
        <configuration>PXM</configuration>
      </member>
      <member>
        <project>Peripheral_Lib</project>
        <configuration>PXR</configuration>
      </member>
      <member>
        <project>Peripheral_Lib</project>
        <configuration>TIC</configuration>
      </member>
      <member>
        <project>Peripheral_Lib</project>
        <configuration>TIS</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


